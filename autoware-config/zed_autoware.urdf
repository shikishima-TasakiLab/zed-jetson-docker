Commit message: URDFの表示設定を追加

File: autoware-config/zed_autoware.urdf (robot description, URDF)
Before this commit: robot zed_camera, 6 links, 5 joints
Joints:
- joint zed_camera_center_joint: origin xyz=0 0 0.35 rpy=0 0 0 -> xyz=0.05 0 0.35 rpy=0 0 0
